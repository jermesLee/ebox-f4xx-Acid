# Keil uVision project stm32f4xx.uvprojx, settings and files
target STM32F4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ebox_stm32f4xx +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,HSE_VALUE = 24000000
  c include: ..\..\..\mcu\stm32f4xx\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\mcu\stm32f4xx\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\User;..\..\..\Driver;..\..\..\common\fat_fs;..\..\..\mcu\stm32f4xx\ebox;..\..\..\common\edriver;..\..\..\common\edriver\SFUD\sfud\inc;..\..\..\common\util;..\..\..\common\cJSON;..\..\..\common\gui;..\..\..\common\network
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../../mcu/stm32f4xx/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../../mcu/stm32f4xx/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries
    ../../../mcu/stm32f4xx/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ebox
    ../../../mcu/stm32f4xx/ebox/: ebox_core.cpp ebox_common.cpp ebox_gpio.cpp ebox_uart.cpp ebox_adc.cpp ebox_it.cpp ebox_dac.cpp ebox_time.cpp ebox_pwm.cpp ebox_spi.cpp ebox_soft_spi.cpp ebox_i2c.cpp ebox_soft_iic.cpp ebox_object.cpp
  group util
    ../../../common/util/: heap.c ebox_mem.c dtostrf.c itoa.c calendar.cpp color_convert.cpp ringbuf.cpp WString.cpp list.cpp crc.c util.cpp
  group Driver
    ../../../Driver/: fsmc_sram.c
  group edriver
    ../../../common/edriver/: 74HC595.cpp Button.cpp dht11.cpp parallel_gpio.cpp led.cpp ds18b20.cpp lcd_1.8.cpp w5500.cpp
  group network
    ../../../common/network/: dhcp.cpp dns.cpp socket.cpp tcp.cpp udp.cpp
  group cJSON
    ../../../common/cJSON/: cJSON.c
  group sfud
    ../../../common/edriver/SFUD/sfud/src/: sfud.c sfud_sfdp.c
    ../../../common/edriver/SFUD/ebox/: ebox_sfud_port.cpp
  group GUI
    ../../../common/gui/: gui.cpp lcd_port.cpp Font8_ASCII.cpp Font16_ASCII.cpp Font16_HZ.cpp Font24_ASCII.cpp Font32_ASCII.cpp
  group User
    ../../../User/: main.cpp bsp.cpp
software components: CMSIS:CORE 4.3.0
